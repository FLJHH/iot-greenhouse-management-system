# Keil uVision project ADC.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ADC +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\LCD;..\HARDWARE\ADC;..\HARDWARE\oled;..\HARDWARE\key;..\HARDWARE\timer;..\HARDWARE\PWM;..\HARDWARE\RFID;..\HARDWARE\PID;..\COMMEN;..\USER;..\HARDWARE\mpu6050;..\HARDWARE\GPIO;..\HARDWARE\VisualScope;..\HARDWARE\Usart;..\HARDWARE\encoder;..\HARDWARE\IIC;..\HARDWARE\LDC1314;..\HARDWARE\dht11;..\HARDWARE\ws2812b;..\HARDWARE\HX711;..\HARDWARE\chaoshengbo;..\HARDWARE\DS18B20
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c include.h
  group HARDWARE
    ../HARDWARE/PID/: PID.c
    ../HARDWARE/RFID/: rc522.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/oled/: oled.c
    ../HARDWARE/key/: key.c
    ../HARDWARE/timer/: timer.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/mpu6050/: inv_mpu.c inv_mpu_dmp_motion_driver.c MPU6050.c STM32_I2C.c
    ../HARDWARE/GPIO/: GPIO.C
    ../HARDWARE/Usart/: usart.c
    ../HARDWARE/encoder/: encoder.c
    ../HARDWARE/LDC1314/: ldc.c myiic.c
    ../HARDWARE/dht11/: dht11.c
    ../HARDWARE/ws2812b/: ws2812b.c
    ../HARDWARE/HX711/: HX711.c
    ../HARDWARE/chaoshengbo/: UltrasonicWave.c
    ../HARDWARE/DS18B20/: ds18B20.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_adc.c stm32f10x_tim.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_wwdg.c
    ../STM32F10x_FWLib/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group COMMON
    ./: protocol.c ringbuffer.c soft_timer.c
    ../COMMEN/: common.h
    ../HARDWARE/VisualScope/: visualscope.c
  group New Group
    ./: doc.txt
